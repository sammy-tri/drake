Commit message: Update mass and intertia to match measurements of the robot toy.

File: examples/kuka_iiwa_arm/models/objects/big_robot_toy.urdf (robot description, URDF)
Before this commit: robot big_robot_toy, 1 links, 0 joints
Links:
- link base_link: mass 0.1 -> 0.143
